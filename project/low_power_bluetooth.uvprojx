# Keil uVision project low_power_bluetooth.uvprojx, settings and files
target low_energy_bluetooth (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ble_app_profile_580 +hex
  c flags: Optim=4 wLevel=2
  c misc: --c99 --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused.txt"
  c include: .\..\;.\..\src\sdk\platform\include;C:\Keil\ARM\RV31\INC;c:\Keil\ARM\CMSIS\Include;.\..\src\sdk\app_modules\api;.\..\src\sdk\app_modules\src\app_bass;.\..\src\sdk\app_modules\src\app_custs;.\..\src\sdk\app_modules\src\app_diss;.\..\src\sdk\app_modules\src\app_findme;.\..\src\sdk\app_modules\src\app_multi_bond;.\..\src\sdk\app_modules\src\app_proxr;.\..\src\sdk\app_modules\src\app_spotar;.\..\src\sdk\ble_stack\controller\em;.\..\src\sdk\ble_stack\controller\llc;.\..\src\sdk\ble_stack\controller\lld;.\..\src\sdk\ble_stack\controller\llm;.\..\src\sdk\ble_stack\hcic;.\..\src\sdk\ble_stack\hcih;.\..\src\sdk\ble_stack\host\att;.\..\src\sdk\ble_stack\host\att\attc;.\..\src\sdk\ble_stack\host\att\attm;.\..\src\sdk\ble_stack\host\att\atts;.\..\src\sdk\ble_stack\host\gap;.\..\src\sdk\ble_stack\host\gap\gapc;.\..\src\sdk\ble_stack\host\gap\gapm;.\..\src\sdk\ble_stack\host\gatt;.\..\src\sdk\ble_stack\host\gatt\gattc;.\..\src\sdk\ble_stack\host\gatt\gattm;.\..\src\sdk\ble_stack\host\l2c\l2cc;.\..\src\sdk\ble_stack\host\l2c\l2cm;.\..\src\sdk\ble_stack\host\smp\smpc;.\..\src\sdk\ble_stack\host\smp\smpm;.\..\src\sdk\ble_stack\host\smp;.\..\src\sdk\ble_stack\profiles\accel;.\..\src\sdk\ble_stack\profiles\adc_notify;.\..\src\sdk\ble_stack\profiles\anc\ancc;.\..\src\sdk\ble_stack\profiles\anc;.\..\src\sdk\ble_stack\profiles\anp\anpc;.\..\src\sdk\ble_stack\profiles\anp\anps;.\..\src\sdk\ble_stack\profiles\anp;.\..\src\sdk\ble_stack\profiles\bas\basc;.\..\src\sdk\ble_stack\profiles\bas\bass;.\..\src\sdk\ble_stack\profiles\blp\blpc;.\..\src\sdk\ble_stack\profiles\blp\blps;.\..\src\sdk\ble_stack\profiles\blp;.\..\src\sdk\ble_stack\profiles\cpp\cppc;.\..\src\sdk\ble_stack\profiles\cpp\cpps;.\..\src\sdk\ble_stack\profiles\cpp;.\..\src\sdk\ble_stack\profiles\cscp\cscpc;.\..\src\sdk\ble_stack\profiles\cscp\cscps;.\..\src\sdk\ble_stack\profiles\cscp;.\..\src\sdk\ble_stack\profiles\custom;.\..\src\sdk\ble_stack\profiles\custom\custs;.\..\src\sdk\ble_stack\profiles\device_config;.\..\src\sdk\ble_stack\profiles\dis\disc;.\..\src\sdk\ble_stack\profiles\dis\diss;.\..\src\sdk\ble_stack\profiles\find\findl;.\..\src\sdk\ble_stack\profiles\find\findt;.\..\src\sdk\ble_stack\profiles\glp\glpc;.\..\src\sdk\ble_stack\profiles\glp\glps;.\..\src\sdk\ble_stack\profiles\glp;.\..\src\sdk\ble_stack\profiles\hogp\hogpbh;.\..\src\sdk\ble_stack\profiles\hogp\hogpd;.\..\src\sdk\ble_stack\profiles\hogp\hogprh;.\..\src\sdk\ble_stack\profiles\hogp;.\..\src\sdk\ble_stack\profiles\hrp\hrpc;.\..\src\sdk\ble_stack\profiles\hrp\hrps;.\..\src\sdk\ble_stack\profiles\hrp;.\..\src\sdk\ble_stack\profiles\htp\htpc;.\..\src\sdk\ble_stack\profiles\htp\htpt;.\..\src\sdk\ble_stack\profiles\htp;.\..\src\sdk\ble_stack\profiles\ieu;.\..\src\sdk\ble_stack\profiles\lan\lanc;.\..\src\sdk\ble_stack\profiles\lan\lans;.\..\src\sdk\ble_stack\profiles\lan;.\..\src\sdk\ble_stack\profiles\mpu;.\..\src\sdk\ble_stack\profiles\pasp\paspc;.\..\src\sdk\ble_stack\profiles\pasp\pasps;.\..\src\sdk\ble_stack\profiles\pasp;.\..\src\sdk\ble_stack\profiles;.\..\src\sdk\ble_stack\profiles\prox\proxm;.\..\src\sdk\ble_stack\profiles\prox\proxr;.\..\src\sdk\ble_stack\profiles\rscp\rscpc;.\..\src\sdk\ble_stack\profiles\rscp\rscps;.\..\src\sdk\ble_stack\profiles\rscp;.\..\src\sdk\ble_stack\profiles\sample128;.\..\src\sdk\ble_stack\profiles\scpp\scppc;.\..\src\sdk\ble_stack\profiles\scpp\scpps;.\..\src\sdk\ble_stack\profiles\scpp;.\..\src\sdk\ble_stack\profiles\spota\spotar;.\..\src\sdk\ble_stack\profiles\streamdata\streamdatad;.\..\src\sdk\ble_stack\profiles\streamdata\streamdatah;.\..\src\sdk\ble_stack\profiles\tip\tipc;.\..\src\sdk\ble_stack\profiles\tip\tips;.\..\src\sdk\ble_stack\profiles\tip;.\..\src\sdk\ble_stack\profiles\uds\udss;.\..\src\sdk\ble_stack\profiles\uds;.\..\src\sdk\ble_stack\profiles\wpt\wptc;.\..\src\sdk\ble_stack\profiles\wpt\wpts;.\..\src\sdk\ble_stack\profiles\wpt;.\..\src\sdk\ble_stack\profiles\wss\wsss;.\..\src\sdk\ble_stack\rwble;.\..\src\sdk\ble_stack\rwble_hl;.\..\src\sdk\common_project_files;.\..\src\sdk\platform\arch;.\..\src\sdk\platform\arch\boot\rvds;.\..\src\sdk\platform\arch\compiler\rvds;.\..\src\sdk\platform\arch\ll\rvds;.\..\src\sdk\platform\arch\main;.\..\src\sdk\platform\arch;.\..\src\sdk\platform\core_modules\arch_console;.\..\src\sdk\platform\core_modules\common\api;.\..\src\sdk\platform\core_modules\crypto;.\..\src\sdk\platform\core_modules\dbg\api;.\..\src\sdk\platform\core_modules\gtl\src;.\..\src\sdk\platform\core_modules\ke\api;.\..\src\sdk\platform\core_modules\ke\src;.\..\src\sdk\platform\core_modules\nvds\api;.\..\src\sdk\platform\core_modules\rf\api;.\..\src\sdk\platform\core_modules\rwip\api;.\..\src\sdk\platform\core_modules\wlan_coex;.\..\src\sdk\platform\driver\accel;.\..\src\sdk\platform\driver\adc;.\..\src\sdk\platform\driver\battery;.\..\src\sdk\platform\driver\bme280;.\..\src\sdk\platform\driver\coex;.\..\src\sdk\platform\driver\coex;.\..\src\sdk\platform\driver\emi;.\..\src\sdk\platform\driver\gpio;.\..\src\sdk\platform\driver\i2c_eeprom;.\..\src\sdk\platform\driver\intc;.\..\src\sdk\platform\driver\inv;.\..\src\sdk\platform\driver\led;.\..\src\sdk\platform\driver\mc3410;.\..\src\sdk\platform\driver\pwm;.\..\src\sdk\platform\driver\rc5;.\..\src\sdk\platform\driver\reg;.\..\src\sdk\platform\driver\sensor;.\..\src\sdk\platform\driver\spi;.\..\src\sdk\platform\driver\spi_439;.\..\src\sdk\platform\driver\spi_flash;.\..\src\sdk\platform\driver\spi_hci;.\..\src\sdk\platform\driver\syscntl;.\..\src\sdk\platform\driver\systick;.\..\src\sdk\platform\driver\trng;.\..\src\sdk\platform\driver\uart;.\..\src\sdk\platform\driver\wkupct_quadec;..\src\main\include;..\src\sdk\platform\core_modules\gtl\api;..\src\ucosii\include;..\src\sps;..\src\sps\config;..\src\sps\driver;..\src\sps\profiles\spss
  library: MicroLIB
  scatter file: .\..\src\sdk\common_project_files\scatterfiles\scatterfile_common.sct
  link misc: --feedback=".\unused.txt" .\..\src\sdk\common_project_files\misc\rom_symdef.txt  --symdefs=ble_app_profile_580_symdef.txt --keep gapm.o(timeout_table_area) --keep jump_table.o(*)  --keep nvds.o(*) --any_placement=best_fit --datacompressor off
  group sdk_boot
    ./../src/sdk/platform/arch/boot/rvds/: system_ARMCM0.c boot_vectors.s
    ./../src/sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    ./../src/sdk/platform/core_modules/arch_console/: arch_console.c
    ./../src/sdk/platform/core_modules/nvds/src/: nvds.c
    ./../src/sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_patch.c
  group sdk_patches
    ./../src/sdk/platform/patch_code/DA14580/obj/: atts_task.obj ch_map.obj gapm_util.obj ke_task.obj smpc.obj smpc_task.obj llc.obj
  group sdk_driver
    ./../src/sdk/platform/driver/syscntl/: syscntl.c
    ./../src/sdk/platform/driver/gpio/: gpio.c
    ./../src/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    ./../src/sdk/platform/driver/battery/: battery.c
    ./../src/sdk/platform/driver/adc/: adc.c
    ./../src/sdk/platform/driver/trng/: trng.c
    ./../src/sdk/platform/driver/spi_flash/: spi_flash.c
    ./../src/sdk/platform/driver/spi/: spi.c
    ../src/sdk/platform/driver/systick/: systick.c
    ../src/sdk/platform/driver/uart/: uart2.c
  group sdk_ble
    ./../src/sdk/platform/core_modules/rf/src/: rf_580.c
    ./../src/sdk/ble_stack/rwble/: rwble.c
    ./../src/sdk/platform/core_modules/rwip/src/: rwip.c
    ./../src/sdk/ble_stack/host/gap/gapm/: gapm.c
  group sdk_profiles
    ./../src/sdk/ble_stack/host/att/attm/: attm_db_128.c
    ./../src/sdk/ble_stack/profiles/dis/diss/: diss.c diss_task.c
    ./../src/sdk/ble_stack/profiles/: prf_utils.c
    ./../src/sdk/ble_stack/profiles/custom/custs/: custs1.c custs1_task.c
    ./../src/sdk/ble_stack/profiles/custom/: custom_common.c
  group sdk_app
    ./../src/sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    ./../src/sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c
    ../src/sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    ./../src/sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    ./../src/sdk/app_modules/src/app_findme/: app_findme.c app_findme_task.c
    ./../src/sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    ./../src/sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    ./../src/sdk/app_modules/src/app_spotar/: app_spotar.c app_spotar_task.c
    ./../src/sdk/app_modules/src/app_entry/: app_entry_point.c
    ./../src/sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_timer.c
    ../src/sdk/app_modules/src/app_easy/: app_easy_security.c
    ./../src/sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
  group sdk_driver_api
    ../src/sdk/platform/driver/adc/: adc.h
    ../src/sdk/platform/driver/battery/: battery.h
    ../src/sdk/platform/driver/gpio/: gpio.h
    ../src/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    ../src/sdk/platform/driver/pwm/: pwm.h
    ../src/sdk/platform/driver/spi/: spi.h
    ../src/sdk/platform/driver/spi_flash/: spi_flash.h
    ../src/sdk/platform/driver/systick/: systick.h
    ../src/sdk/platform/driver/trng/: trng.h
    ../src/sdk/platform/driver/uart/: uart.h
    ../src/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.h
  group sdk_app_api
    ../src/sdk/app_modules/api/: app.h app_api.h app_callback.h app_default_handlers.h app_easy_gap.h app_easy_msg_utils.h app_easy_security.h app_easy_timer.h app_entry_point.h app_mid.h app_msg_utils.h app_security.h app_task.h app_user_config.h
  group sdk_arch_api
    ../src/sdk/platform/arch/: arch_api.h
    ../src/sdk/platform/arch/main/: arch_wdg.h arch_main.h
    ../src/sdk/platform/core_modules/arch_console/: arch_console.h
  group user_config
    ../src/sps/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_config_sw_ver.h user_custs_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group ucosii
    ../src/ucosii/ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
    ../src/ucosii/source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group main
    ../src/main/src/: init.c led_blink.c main.c app_hooks.c ble_queue.c ble_receive.c ble_send.c flash_task.c
  group sps
    ../src/sps/platform/: user_periph_setup.c
    ../src/sps/: user_buffer.c user_sps_scheduler.c user_sps_device.c user_spss.c user_spss_task.c
    ../src/sps/driver/: uart_sps.c
    ../src/sps/profiles/spss/: sps_server.c sps_server_task.c
target ble_app_profile_581 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: ble_app_profile_581 +hex
  c flags: Optim=4 wLevel=2
  c define: __DA14581__
  c misc: as above
  c include: .\..\;.\..\src\sdk\platform\include;C:\Keil\ARM\RV31\INC;c:\Keil\ARM\CMSIS\Include;.\..\src\sdk\app_modules\api;.\..\src\sdk\app_modules\src\app_bass;.\..\src\sdk\app_modules\src\app_custs;.\..\src\sdk\app_modules\src\app_diss;.\..\src\sdk\app_modules\src\app_findme;.\..\src\sdk\app_modules\src\app_multi_bond;.\..\src\sdk\app_modules\src\app_proxr;.\..\src\sdk\app_modules\src\app_spotar;.\..\src\sdk\ble_stack\controller\em;.\..\src\sdk\ble_stack\controller\llc;.\..\src\sdk\ble_stack\controller\lld;.\..\src\sdk\ble_stack\controller\llm;.\..\src\sdk\ble_stack\hcic;.\..\src\sdk\ble_stack\hcih;.\..\src\sdk\ble_stack\host\att;.\..\src\sdk\ble_stack\host\att\attc;.\..\src\sdk\ble_stack\host\att\attm;.\..\src\sdk\ble_stack\host\att\atts;.\..\src\sdk\ble_stack\host\gap;.\..\src\sdk\ble_stack\host\gap\gapc;.\..\src\sdk\ble_stack\host\gap\gapm;.\..\src\sdk\ble_stack\host\gatt;.\..\src\sdk\ble_stack\host\gatt\gattc;.\..\src\sdk\ble_stack\host\gatt\gattm;.\..\src\sdk\ble_stack\host\l2c\l2cc;.\..\src\sdk\ble_stack\host\l2c\l2cm;.\..\src\sdk\ble_stack\host\smp\smpc;.\..\src\sdk\ble_stack\host\smp\smpm;.\..\src\sdk\ble_stack\host\smp;.\..\src\sdk\ble_stack\profiles\accel;.\..\src\sdk\ble_stack\profiles\adc_notify;.\..\src\sdk\ble_stack\profiles\anc\ancc;.\..\src\sdk\ble_stack\profiles\anc;.\..\src\sdk\ble_stack\profiles\anp\anpc;.\..\src\sdk\ble_stack\profiles\anp\anps;.\..\src\sdk\ble_stack\profiles\anp;.\..\src\sdk\ble_stack\profiles\bas\basc;.\..\src\sdk\ble_stack\profiles\bas\bass;.\..\src\sdk\ble_stack\profiles\blp\blpc;.\..\src\sdk\ble_stack\profiles\blp\blps;.\..\src\sdk\ble_stack\profiles\blp;.\..\src\sdk\ble_stack\profiles\cpp\cppc;.\..\src\sdk\ble_stack\profiles\cpp\cpps;.\..\src\sdk\ble_stack\profiles\cpp;.\..\src\sdk\ble_stack\profiles\cscp\cscpc;.\..\src\sdk\ble_stack\profiles\cscp\cscps;.\..\src\sdk\ble_stack\profiles\cscp;.\..\src\sdk\ble_stack\profiles\custom;.\..\src\sdk\ble_stack\profiles\custom\custs;.\..\src\sdk\ble_stack\profiles\device_config;.\..\src\sdk\ble_stack\profiles\dis\disc;.\..\src\sdk\ble_stack\profiles\dis\diss;.\..\src\sdk\ble_stack\profiles\find\findl;.\..\src\sdk\ble_stack\profiles\find\findt;.\..\src\sdk\ble_stack\profiles\glp\glpc;.\..\src\sdk\ble_stack\profiles\glp\glps;.\..\src\sdk\ble_stack\profiles\glp;.\..\src\sdk\ble_stack\profiles\hogp\hogpbh;.\..\src\sdk\ble_stack\profiles\hogp\hogpd;.\..\src\sdk\ble_stack\profiles\hogp\hogprh;.\..\src\sdk\ble_stack\profiles\hogp;.\..\src\sdk\ble_stack\profiles\hrp\hrpc;.\..\src\sdk\ble_stack\profiles\hrp\hrps;.\..\src\sdk\ble_stack\profiles\hrp;.\..\src\sdk\ble_stack\profiles\htp\htpc;.\..\src\sdk\ble_stack\profiles\htp\htpt;.\..\src\sdk\ble_stack\profiles\htp;.\..\src\sdk\ble_stack\profiles\ieu;.\..\src\sdk\ble_stack\profiles\lan\lanc;.\..\src\sdk\ble_stack\profiles\lan\lans;.\..\src\sdk\ble_stack\profiles\lan;.\..\src\sdk\ble_stack\profiles\mpu;.\..\src\sdk\ble_stack\profiles\pasp\paspc;.\..\src\sdk\ble_stack\profiles\pasp\pasps;.\..\src\sdk\ble_stack\profiles\pasp;.\..\src\sdk\ble_stack\profiles;.\..\src\sdk\ble_stack\profiles\prox\proxm;.\..\src\sdk\ble_stack\profiles\prox\proxr;.\..\src\sdk\ble_stack\profiles\rscp\rscpc;.\..\src\sdk\ble_stack\profiles\rscp\rscps;.\..\src\sdk\ble_stack\profiles\rscp;.\..\src\sdk\ble_stack\profiles\sample128;.\..\src\sdk\ble_stack\profiles\scpp\scppc;.\..\src\sdk\ble_stack\profiles\scpp\scpps;.\..\src\sdk\ble_stack\profiles\scpp;.\..\src\sdk\ble_stack\profiles\spota\spotar;.\..\src\sdk\ble_stack\profiles\sps\sps_client;.\..\src\sdk\ble_stack\profiles\sps\sps_server;.\..\src\sdk\ble_stack\profiles\streamdata\streamdatad;.\..\src\sdk\ble_stack\profiles\streamdata\streamdatah;.\..\src\sdk\ble_stack\profiles\tip\tipc;.\..\src\sdk\ble_stack\profiles\tip\tips;.\..\src\sdk\ble_stack\profiles\tip;.\..\src\sdk\ble_stack\profiles\uds\udss;.\..\src\sdk\ble_stack\profiles\uds;.\..\src\sdk\ble_stack\profiles\wpt\wptc;.\..\src\sdk\ble_stack\profiles\wpt\wpts;.\..\src\sdk\ble_stack\profiles\wpt;.\..\src\sdk\ble_stack\profiles\wss\wsss;.\..\src\sdk\ble_stack\rwble;.\..\src\sdk\ble_stack\rwble_hl;.\..\src\sdk\common_project_files;.\..\src\sdk\platform\arch;.\..\src\sdk\platform\arch\boot\rvds;.\..\src\sdk\platform\arch\compiler\rvds;.\..\src\sdk\platform\arch\ll\rvds;.\..\src\sdk\platform\arch\main;.\..\src\sdk\platform\arch;.\..\src\sdk\platform\core_modules\arch_console;.\..\src\sdk\platform\core_modules\common\api;.\..\src\sdk\platform\core_modules\crypto;.\..\src\sdk\platform\core_modules\dbg\api;.\..\src\sdk\platform\core_modules\gtl\src;.\..\src\sdk\platform\core_modules\ke\api;.\..\src\sdk\platform\core_modules\ke\src;.\..\src\sdk\platform\core_modules\nvds\api;.\..\src\sdk\platform\core_modules\rf\api;.\..\src\sdk\platform\core_modules\rwip\api;.\..\src\sdk\platform\core_modules\wlan_coex;.\..\src\sdk\platform\driver\accel;.\..\src\sdk\platform\driver\adc;.\..\src\sdk\platform\driver\battery;.\..\src\sdk\platform\driver\bme280;.\..\src\sdk\platform\driver\coex;.\..\src\sdk\platform\driver\coex;.\..\src\sdk\platform\driver\emi;.\..\src\sdk\platform\driver\gpio;.\..\src\sdk\platform\driver\i2c_BMI055;.\..\src\sdk\platform\driver\i2c_core;.\..\src\sdk\platform\driver\i2c_eeprom;.\..\src\sdk\platform\driver\intc;.\..\src\sdk\platform\driver\inv;.\..\src\sdk\platform\driver\led;.\..\src\sdk\platform\driver\mc3410;.\..\src\sdk\platform\driver\pwm;.\..\src\sdk\platform\driver\rc5;.\..\src\sdk\platform\driver\reg;.\..\src\sdk\platform\driver\sensor;.\..\src\sdk\platform\driver\spi;.\..\src\sdk\platform\driver\spi_439;.\..\src\sdk\platform\driver\spi_flash;.\..\src\sdk\platform\driver\spi_hci;.\..\src\sdk\platform\driver\syscntl;.\..\src\sdk\platform\driver\systick;.\..\src\sdk\platform\driver\trng;.\..\src\sdk\platform\driver\uart;.\..\src\sdk\platform\driver\wkupct_quadec;.\..\src\config;.\..\src;.\..\src\sdk\platform\core_modules\gtl\api
  library: MicroLIB
  scatter file: .\..\src\sdk\common_project_files\scatterfiles\scatterfile_common_581.sct
  link misc: --feedback=".\unused.txt" .\..\src\sdk\common_project_files\misc\rom_symdef_581.txt  --symdefs=ble_app_profile_581_symdef.txt --keep gapm.o(timeout_table_area) --keep jump_table.o(*)  --keep nvds.o(*) --any_placement=best_fit --datacompressor off
target ble_app_profile_583 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: ble_app_profile_583 +hex
  c flags: Optim=4 wLevel=2
  c define: __DA14583__
  c misc: as above
  c include: as above
  library: MicroLIB
  scatter file: as above
  link misc: --feedback=".\unused.txt" .\..\src\sdk\common_project_files\misc\rom_symdef.txt  --symdefs=ble_app_profile_583_symdef.txt --keep gapm.o(timeout_table_area) --keep jump_table.o(*)  --keep nvds.o(*) --any_placement=best_fit --datacompressor off
