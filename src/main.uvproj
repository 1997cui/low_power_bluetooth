# Keil uVision project main.uvproj, settings and files
target Full_emb_cortex_M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: full_emb_sysram +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --thumb -c --preinclude da14580_config.h --bss_threshold=0
  c include: .\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\dialog\include;c:\Keil\ARM\CMSIS\Include;C:\Keil\ARM\RV31\INC;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\plf\refip\src\arch;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\plf\refip\src\arch\compiler\rvds;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\plf\refip\src\arch\boot\rvds;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\plf\refip\src\arch\ll\rvds;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\plf\refip\src\driver\reg;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\modules\common\api;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\modules\dbg\api;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\modules\display\api;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\modules\gtl\api;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\modules\ke\api;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\modules\ke\src;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\modules\nvds\api;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\modules\rf\api;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\modules\rwip\api;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\ll\src\rwble;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\ll\src\controller\em;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\ll\src\controller\llc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\ll\src\controller\lld;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\ll\src\controller\llm;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\plf\refip\src\driver\led;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\plf\refip\src\driver\timer;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\plf\refip\src\driver\syscntl;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\plf\refip\src\driver\emi;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\plf\refip\src\driver\uart;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\plf\refip\src\driver\flash;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\plf\refip\src\driver\gpio;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\host\att;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\host\att\attc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\host\att\attm;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\host\gap;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\host\gap\gapc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\host\gap\gapm;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\host\att\atts;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\host\gatt;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\host\gatt\gattc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\host\gatt\gattm;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\host\l2c\l2cc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\host\l2c\l2cm;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\host\smp\smpc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\host\smp\smpm;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\accel;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\bas\basc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\bas\bass;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\blp;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\blp\blpc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\blp\blps;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\dis\disc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\dis\diss;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\find\findl;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\find\findt;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\hogp;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\hogp\hogpbh;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\hogp\hogpd;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\hogp\hogprh;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\hrp;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\hrp\hrpc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\hrp\hrps;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\htp;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\htp\htpc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\htp\htpt;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\prox\proxm;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\prox\proxr;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\scpp;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\scpp\scppc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\scpp\scpps;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\plf\refip\src\driver\intc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\rwble_hl;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\ll\src\hcic;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\host\smp;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\modules\app\api;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\modules\gtl\src;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\anp;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\anp\anpc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\anp\anps;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\cscp;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\cscp\cscpc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\cscp\cscps;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\glp;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\glp\glpc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\glp\glps;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\pasp;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\pasp\paspc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\pasp\pasps;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\rscp;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\rscp\rscpc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\rscp\rscps;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\tip;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\tip\tipc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\tip\tips;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\cpp;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\cpp\cppc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\cpp\cpps;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\lan;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\lan\lanc;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\ip\ble\hl\src\profiles\lan\lans;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\modules\app\src\;.;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\plf\refip\src\driver\adc;.\system;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\plf\refip\src\driver\wkupct;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\plf\refip\src\driver\battery;.\..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\src\modules\app\src\app_utils\app_console
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x5000
  memory RVCT5: ROM 0x21000 size 0x13f00
  memory RVCT9: RAM 0x20005100 size 0x5600
  memory RVCT10: RAM 0x8000 size 0x1000
  scatter file: ..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\scatterfiles\scatterfile_common.sct
  link misc: ..\orig_src\DA14580_SDK_3.0.4.0\dk_apps\misc\rom_symdef.txt  --symdefs=full_emb_sysram_symdef.txt --keep gapm.o(timeout_table_area) --keep jump_table.o(*)  --keep nvds.o(*) --any_placement=best_fit --datacompressor off
  group boot
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/plf/refip/src/arch/boot/rvds/: system_ARMCM0.c boot_vectors.s
    ../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/plf/refip/src/arch/main/ble/: hardfault_handler.c
  group arch
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/plf/refip/src/arch/main/ble/: arch_main.c jump_table.c
    ../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/plf/refip/src/arch/main/ble/: arch_sleep.c nmi_handler.c arch_system.c
    ./system/: periph_setup.c
  group driver
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/modules/rf/src/: rf_580.c
    ../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/plf/refip/src/driver/gpio/: gpio.c
    ../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/plf/refip/src/driver/uart/: uart2.c
  group ke
    ../orig_src/DA14580_SDK_3.0.4.0/dk_apps/patch_code/obj/: ke_task.obj ch_map.obj
  group host
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/host/gap/gapm/: gapm.c
    ../orig_src/DA14580_SDK_3.0.4.0/dk_apps/patch_code/obj/: atts_task.obj smpc.obj smpc_task.obj gapm_util.obj
  group nvds
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/modules/nvds/src/: nvds.c
  group rwble
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/modules/rwip/src/: rwip.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/ll/src/rwble/: rwble.c
  group profiles
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/accel/: accel.c accel_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/bas/basc/: basc.c basc_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/bas/bass/: bass.c bass_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/blp/blpc/: blpc.c blpc_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/blp/blps/: blps.c blps_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/dis/disc/: disc.c disc_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/dis/diss/: diss.c diss_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/find/findt/: findt.c findt_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/hogp/hogpbh/: hogpbh.c hogpbh_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/hogp/hogpd/: hogpd.c hogpd_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/hogp/hogprh/: hogprh.c hogprh_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/hrp/hrpc/: hrpc.c hrpc_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/hrp/hrps/: hrps.c hrps_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/htp/htpc/: htpc.c htpc_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/htp/htpt/: htpt.c htpt_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/prox/proxm/: proxm.c proxm_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/prox/proxr/: proxr.c proxr_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/scpp/scppc/: scppc.c scppc_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/scpp/scpps/: scpps.c scpps_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/: prf_utils.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/anp/anpc/: anpc.c anpc_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/anp/anps/: anps.c anps_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/cscp/cscpc/: cscpc.c cscpc_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/cscp/cscps/: cscps.c cscps_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/glp/glpc/: glpc.c glpc_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/glp/glps/: glps.c glps_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/pasp/paspc/: paspc.c paspc_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/pasp/pasps/: pasps.c pasps_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/rscp/rscpc/: rscpc.c rscpc_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/rscp/rscps/: rscps.c rscps_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/tip/tipc/: tipc.c tipc_task.c
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/tip/tips/: tips.c tips_task.c
    ../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/find/findl/: findl.c findl_task.c
    ../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/cpp/cppc/: cppc.c cppc_task.c
    ../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/cpp/cpps/: cpps.c cpps_task.c
    ../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/lan/lanc/: lanc.c lanc_task.c
    ../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/ip/ble/hl/src/profiles/lan/lans/: lans.c lans_task.c
  group app
    ./../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/modules/app/src/: app.c app_sec.c app_sec_task.c app_task.c
    ./: main.c
    ../orig_src/DA14580_SDK_3.0.4.0/dk_apps/src/modules/app/src/app_utils/app_console/: app_console.c
