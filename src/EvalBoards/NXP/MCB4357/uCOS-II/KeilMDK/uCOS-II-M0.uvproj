# Keil uVision project uCOS-II-M0.uvproj, settings and files
target uCOS-II M0 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: uCOS-II
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M0
  c include: ..\;..\..\BSP;..\..\BSP\KeilMDK;..\..\..\..\..\uC-CPU;..\..\..\..\..\uC-CPU\ARM-Cortex-M0\RealView;..\..\..\..\..\uC-LIB;..\..\..\..\..\uCOS-II\Source;..\..\..\..\..\uCOS-II\Ports\ARM-Cortex-M0\Generic\RealView
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group APP
    ../: app.c app_cfg.h app_hooks.c cpu_cfg.h lib_cfg.h os_cfg.h
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c bsp_int.h cpu_bsp.c
    ../../BSP/KeilMDK/: cstartup.s LPC43xx_TP.ini
  group uC/CPU
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/CPU Port-M0
    ../../../../../uC-CPU/ARM-Cortex-M0/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uCOS-II Source
    ../../../../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uCOS-II Port-M0
    ../../../../../uCOS-II/Ports/ARM-Cortex-M0/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
