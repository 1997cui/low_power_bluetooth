# Keil uVision project LPC11xx_ucos_ii.uvproj, settings and files
target lpc11xx_ucos_ii (ARM-ADS)
  device: LPC1114x301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: LPC11xx_ucos_ii +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG_FLASH
  c include: .\src\user;.\src\UCOS2_PORT;.\src\UCOS2_SOURCE;.\src\lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group user_code
    ./src/user/: device_init.c main.c
  group startup_code
    ./src/lib/src/: startup_LPC11xx.s system_LPC11xx.c core_cm0.c
  group common_code
    ./src/user/: systick.c
    ./src/lib/src/: gpio.c
  group ports
    ./src/UCOS2_PORT/: os_cpu_c.c cpu_a.asm os_cpu_a.asm cpu.h cpu_def.h os_cpu.h
  group ucos_ii_src
    ./src/UCOS2_SOURCE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
